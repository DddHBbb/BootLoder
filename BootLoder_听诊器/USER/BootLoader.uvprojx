# Keil uVision project BootLoader.uvprojx, settings and files
target BootLoader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BootLoader +hex
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ..\CORE;..\OBJ;..\USER;..\HALLIB\STM32F4xx_HAL_Driver\Inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\SDRAM;..\HARDWARE\KEY;..\HARDWARE\SDIO;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\HARDWARE\NAND;..\MALLOC;..\USMART;..\FATFS\exfuns;..\FATFS\src;..\HARDWARE\IAP;..\HARDWARE\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: core_cm4.h cmsis_armcc.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f429xx.s
  group HALLIB
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_sdram.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_nand.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/IAP/: IAP.c
    ../HARDWARE/OLED/: oled.c
  group FATFS
    ../FATFS/src/: ff.c diskio.c
    ../FATFS/exfuns/: exfuns.c fattester.c
    ../FATFS/src/option/: cc936.c
  group README
    ../: readme.txt
